# Keil uVision project QSPI.uvprojx, settings and files
target QSPI (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H750VBTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 v6Lang=6 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER, STM32H750xx
  c include: ..\CORE;..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HALLIB\STM32H7xx_HAL_Driver\Inc;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\TIMER;..\HARDWARE\24CXX;..\HARDWARE\QSPI;..\HARDWARE\P25QXX;..\HARDWARE\SWITCH;..\HARDWARE\ADC;..\HARDWARE\EXTI;..\HARDWARE\OLED;..\HARDWARE\AD5761;..\HARDWARE\LTC2631;..\HARDWARE\EX-P25QXX;..\HARDWARE\SPI;..\HARDWARE\POWER;..\HARDWARE\IIC;..\HARDWARE\DATA
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group USER
    ./: main.c stm32h7xx_it.c system_stm32h7xx.c stm32h7xx_hal_msp.c
  group CORE
    ../CORE/: core_cm7.h cmsis_armcc.h cmsis_compiler.h startup_stm32h750xx.s
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HALLIB
    ../HALLIB/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_ll_fmc.c stm32h7xx_hal_qspi.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/QSPI/: qspi.c
    ../HARDWARE/SWITCH/: switch.c
    ../HARDWARE/P25QXX/: p25qxx.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/OLED/: OLED_I2C.c
    ../HARDWARE/AD5761/: ad5761r.c
    ../HARDWARE/LTC2631/: LTC2631.c
    ../HARDWARE/EX-P25QXX/: ex_p25qxx.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/POWER/: power.c
    ../HARDWARE/IIC/: iic.c
    ../HARDWARE/DATA/: data.c
  group COMMAND
    ../CMD/: CommonCMD.c SPI_CMD.c FLASH_CMD.c
